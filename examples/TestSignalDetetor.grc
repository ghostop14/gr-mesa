options:
  parameters:
    generate_options: qt_gui
    id: test_sig_detector
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,2
    label: Frequency
    type: real
    value: 162.425e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: LNA Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '50'
    value: '32'
  states: {}
- name: maxWidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,2,1,2
    label: Max Detect Width
    type: real
    value: 60e3
  states: {}
- name: minWidth
  id: variable_qtgui_entry
  parameters:
    comment: 'Or 2 FFT buckets: samp_rate/1024*2.0'
    gui_hint: 2,0,1,2
    label: Min Detect Width
    type: real
    value: 6e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    label: Squelch
    orient: Qt.Horizontal
    start: '-100.0'
    step: '5.0'
    stop: '-10.0'
    value: '-75.0'
  states: {}
- name: src_airspy
  id: variable
  parameters:
    value: '''airspy'''
  states: {}
- name: src_spyserver
  id: variable
  parameters:
    value: '''host=192.168.254.138,port=5555,spyserver=0'''
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1.5'
    value: '0.25'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: filerepeater_file_repeater_ex_0
  id: filerepeater_file_repeater_ex
  parameters:
    complexconv: '0'
    delayFirstStart: '0.0'
    file: /opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_NoFilter.iq
    repeat: 'True'
    repeat_delay: '0'
    repeat_times: '0'
    type: complex
    verbose: 'False'
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mesa_SignalDetector_0
  id: mesa_SignalDetector
  parameters:
    detectionMethod: '1'
    enableDebug: 'False'
    fft_size: '1024'
    framesToAvg: '6'
    genSignalPDUs: 'False'
    holdUpSec: '10.0'
    maxWidthHz: '60000.0'
    minWidthHz: '6000.0'
    radioCenterFreq: freq
    sampleRate: samp_rate
    squelchThreshold: '-80.0'
  states: {}
- name: osmosdr_source_0_1_1
  id: osmosdr_source
  parameters:
    args: src_spyserver
    bb_gain0: '20'
    freq0: freq
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 5,0,2,4
    label1: Direct
    label2: Detector
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0,2,4
    legend: 'False'
    name: '"Raw Input"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-100'
  states: {}

connections:
- [filerepeater_file_repeater_ex_0, '0', mesa_SignalDetector_0, '0']
- [filerepeater_file_repeater_ex_0, '0', qtgui_freq_sink_x_0, '0']
- [filerepeater_file_repeater_ex_0, '0', qtgui_freq_sink_x_0_0, '0']
- [mesa_SignalDetector_0, '0', qtgui_freq_sink_x_0, '1']
- [mesa_SignalDetector_0, signaldetect, blocks_message_debug_0, print]
- [osmosdr_source_0_1_1, '0', mesa_SignalDetector_0, '0']
- [osmosdr_source_0_1_1, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0_1_1, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
