<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_sig_detector</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lna_gain</value></param>
<param><key>value</key><value>32</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>maxWidth</value></param>
<param><key>value</key><value>60e3</value></param>
<param><key>label</key><value>Max Width Hz</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>minWidth</value></param>
<param><key>comment</key><value>Or 2 FFT buckets: samp_rate/1024*2.0</value></param>
<param><key>value</key><value>6e3</value></param>
<param><key>label</key><value>Min Width Hz</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>-75.0</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100.0</value></param>
<param><key>step</key><value>5.0</value></param>
<param><key>stop</key><value>-10.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_airspy</value></param>
<param><key>value</key><value>'airspy'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_spyserver</value></param>
<param><key>value</key><value>'host=192.168.254.138,port=5555,spyserver=0'</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>basedir</key><value>/tmp</value></param>
<param><key>basefile</key><value>gr_record</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>radioCenterFreq</key><value>freq</value></param>
<param><key>honorFreqChange</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>True</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>mesa_MesaEnergyDetector</key>
<param><key>id</key><value>mesa_MesaEnergyDetector_0</value></param>
<param><key>enableDebug</key><value>False</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>framesToAvg</key><value>int(math.ceil(0.015*samp_rate/1024))</value></param>
<param><key>genSignalPDUs</key><value>False</value></param>
<param><key>holdUpSec</key><value>5.0</value></param>
<param><key>maxWidthHz</key><value>maxWidth</value></param>
<param><key>minWidthHz</key><value>minWidth</value></param>
<param><key>radioCenterFreq</key><value>freq</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>squelchThreshold</key><value>squelch</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>lna_gain</value></param>
<param><key>gain0</key><value>lna_gain</value></param>
<param><key>comment</key><value>Airspy Config</value></param>
<param><key>args</key><value>src_spyserver</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Direct</value></param>
<param><key>label2</key><value>Detector</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,2,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Raw Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<connection><source_block_id>mesa_MesaEnergyDetector_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mesa_MesaEnergyDetector_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>signaldetect</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>mesa_MesaEnergyDetector_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>signaldetect</source_key><sink_key>recordstate</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>mesa_MesaEnergyDetector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
