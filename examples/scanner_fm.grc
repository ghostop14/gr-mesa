options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: scanner_fm
    output_language: python
    title: NBFM Scanner
  states: {}

blocks:
- name: freq
  id: mesa_VariableRotator
  parameters:
    rotationTime: '2.0'
    valueList: '[158.355e6,461.8375e6,656.2125e6]'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '40'
  states: {}
- name: guiextra_msgdigitalnumbercontrol_0
  id: guiextra_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: ','
    gui_hint: 0,0,1,1
    lbl: ''
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    outputmsgname: freq
    readOnly: 'True'
    relBackgroundColor: black
    relFontColor: white
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: scanner_dir
  id: variable
  parameters:
    value: '"/opt/tmp/scanner"'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Sig Detect Threshold
    orient: Qt.Horizontal
    start: '-80'
    step: '2'
    stop: '-40'
    value: '-68'
  states: {}
- name: variable_qtgui_toggle_button_msg_0
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 2,0,1,1
    initPressed: 'False'
    label: Lock Channel
    pressBackgroundColor: green
    pressed: '1'
    relBackgroundColor: blue
    released: '0'
    type: int
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0.2'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 3e3
    quad_rate: int(480e3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 3e3
    quad_rate: int(480e3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 3e3
    quad_rate: int(480e3)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: volume
    type: float
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: scanner_dir
    basefile: ch1
    bits_per_sample: '8'
    honorFreqChange: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: '48000'
    type: floatwav
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_AdvFileSink_0_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: scanner_dir
    basefile: ch2
    bits_per_sample: '8'
    honorFreqChange: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: '48000'
    type: floatwav
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_AdvFileSink_0_0_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: scanner_dir
    basefile: ch3
    bits_per_sample: '8'
    honorFreqChange: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: '48000'
    type: floatwav
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_StateOr_0
  id: filerepeater_StateOr
  parameters: {}
  states: {}
- name: lfast_low_pass_filter_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    comment: |-
      NBFM.  12.5 kHz.  Set to 14 kHz
      FFT LPF is more efficient
    cutoff_freq: 7e3
    decim: '5'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: mesa_SignalDetector_0
  id: mesa_SignalDetector
  parameters:
    comment: |-
      This detects if a signal is present, and if it is, emits a state high message. 
      The variable rotator processes that message as a hold-the-rotation message.
    detectionMethod: '1'
    enableDebug: 'False'
    fft_size: '1024'
    framesToAvg: '6'
    genSignalPDUs: 'False'
    holdUpSec: '3.0'
    maxWidthHz: '14000.0'
    minWidthHz: '6000.0'
    radioCenterFreq: freq
    sampleRate: int(samp_rate/5)
    squelchThreshold: threshold
  states: {}
- name: mesa_SignalDetector_0_0
  id: mesa_SignalDetector
  parameters:
    comment: |-
      This detects if a signal is present, and if it is, emits a state high message. 
      The variable rotator processes that message as a hold-the-rotation message.
    detectionMethod: '1'
    enableDebug: 'False'
    fft_size: '1024'
    framesToAvg: '6'
    genSignalPDUs: 'False'
    holdUpSec: '3.0'
    maxWidthHz: '14000.0'
    minWidthHz: '6000.0'
    radioCenterFreq: freq
    sampleRate: int(samp_rate/5)
    squelchThreshold: '-50.0'
  states: {}
- name: mesa_SignalDetector_0_0_0
  id: mesa_SignalDetector
  parameters:
    detectionMethod: '1'
    enableDebug: 'False'
    fft_size: '1024'
    framesToAvg: '6'
    genSignalPDUs: 'False'
    holdUpSec: '3.0'
    maxWidthHz: '14000.0'
    minWidthHz: '6000.0'
    radioCenterFreq: freq
    sampleRate: int(samp_rate/5)
    squelchThreshold: '-58.0'
  states: {}
- name: mesa_SignalDetector_0_0_0_0
  id: mesa_SignalDetector
  parameters:
    detectionMethod: '1'
    enableDebug: 'False'
    fft_size: '1024'
    framesToAvg: '6'
    genSignalPDUs: 'False'
    holdUpSec: '3.0'
    maxWidthHz: '14000.0'
    minWidthHz: '6000.0'
    radioCenterFreq: freq
    sampleRate: int(samp_rate/5)
    squelchThreshold: '-68.0'
  states: {}
- name: mesa_ioselector_0
  id: mesa_ioselector
  parameters:
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: '0'
    type: complex
    vlen: '1'
  states: {}
- name: mesa_ioselector_1
  id: mesa_ioselector
  parameters:
    input_index: '0'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Each of these paths can process ths signal differently if necessary.
      For this example they all do the same thing, decode a NBFM voice channel.
    note: Note
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: If these blocks are missing, install gr-filerepeater
    note: Note
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: If this block is missing, install gr-guiextra
    note: Note
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    comment: If FFT LPF block is missing, install gr-lfast
    note: Note
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0,1,4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-90'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', filerepeater_AdvFileSink_0, '0']
- [analog_nbfm_rx_0, '0', mesa_ioselector_1, '0']
- [analog_nbfm_rx_0_0, '0', filerepeater_AdvFileSink_0_0, '0']
- [analog_nbfm_rx_0_0, '0', mesa_ioselector_1, '1']
- [analog_nbfm_rx_0_0_0, '0', filerepeater_AdvFileSink_0_0_0, '0']
- [analog_nbfm_rx_0_0_0, '0', mesa_ioselector_1, '2']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [filerepeater_StateOr_0, state, freq, hold]
- [freq, index, mesa_ioselector_0, outputindex]
- [freq, index, mesa_ioselector_1, inputindex]
- [lfast_low_pass_filter_0, '0', mesa_SignalDetector_0, '0']
- [mesa_SignalDetector_0, '0', mesa_ioselector_0, '0']
- [mesa_SignalDetector_0, state, filerepeater_StateOr_0, state2]
- [mesa_SignalDetector_0_0, '0', analog_nbfm_rx_0, '0']
- [mesa_SignalDetector_0_0, state, filerepeater_AdvFileSink_0, recordstate]
- [mesa_SignalDetector_0_0_0, '0', analog_nbfm_rx_0_0, '0']
- [mesa_SignalDetector_0_0_0, state, filerepeater_AdvFileSink_0_0, recordstate]
- [mesa_SignalDetector_0_0_0_0, '0', analog_nbfm_rx_0_0_0, '0']
- [mesa_SignalDetector_0_0_0_0, state, filerepeater_AdvFileSink_0_0_0, recordstate]
- [mesa_ioselector_0, '0', mesa_SignalDetector_0_0, '0']
- [mesa_ioselector_0, '1', mesa_SignalDetector_0_0_0, '0']
- [mesa_ioselector_0, '2', mesa_SignalDetector_0_0_0_0, '0']
- [mesa_ioselector_1, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_1, '0', lfast_low_pass_filter_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']
- [variable_qtgui_toggle_button_msg_0, state, filerepeater_StateOr_0, state1]

metadata:
  file_format: 1
