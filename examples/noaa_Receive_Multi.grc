<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>noaa_receiver_multi</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>comment</key><value>Must be a pure #</value></param>
<param><key>value</key><value>137.1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_north</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>2,3,1,3</value></param>
<param><key>label</key><value>EQ North</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>6.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_south</value></param>
<param><key>value</key><value>1.1</value></param>
<param><key>gui_hint</key><value>2,0,1,3</value></param>
<param><key>label</key><value>EQ South</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_cutoff</value></param>
<param><key>value</key><value>20000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_width</value></param>
<param><key>comment</key><value>34kHz</value></param>
<param><key>value</key><value>34000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framesToAvg</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host</value></param>
<param><key>comment</key><value>225 = sigintsouth
206 = sigintnorth
99 sigintwifi / 100 wired</value></param>
<param><key>value</key><value>'192.168.254.225'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host2</value></param>
<param><key>value</key><value>'192.168.254.206'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_15</value></param>
<param><key>value</key><value>137.62e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_18</value></param>
<param><key>value</key><value>137.9125e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_19</value></param>
<param><key>value</key><value>137.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_freq</value></param>
<param><key>value</key><value>noaa_19</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>480000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelchThreshold</value></param>
<param><key>value</key><value>-67.0</value></param>
<param><key>gui_hint</key><value>0,4,1,2</value></param>
<param><key>label</key><value>squelch threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>-20.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_spyserver</value></param>
<param><key>value</key><value>'host='+host+',port=5555,spyserver=0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_spyserver2</value></param>
<param><key>value</key><value>'host='+host2+',port=5555,spyserver=0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>stage1_decimation</value></param>
<param><key>value</key><value>int(samp_rate/500e3)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol</value></param>
<param><key>value</key><value>1.8</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>3</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>radio_freq - doppler_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>quad_rate</key><value>441000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>comment</key><value>Loopback to image processor</value></param>
<param><key>device_name</key><value>jack_playback_1</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>vol</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>eq_south</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>eq_north</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>comment</key><value>Correct for Doppler</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>comment</key><value>Correct for Doppler</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>edit_box_input_freq</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>key</key><value>freq</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>137.912e6</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>False</value></param>
<param><key>basedir</key><value>/mnt/data/recordings</value></param>
<param><key>basefile</key><value>noaa</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>comment</key><value>WAV files need to be at 11025 to decode</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>radioCenterFreq</key><value>radio_freq</value></param>
<param><key>honorFreqChange</key><value>False</value></param>
<param><key>type</key><value>floatwav</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>False</value></param>
<param><key>sampleRate</key><value>11025</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0_0</value></param>
<param><key>autostartFreqChange</key><value>False</value></param>
<param><key>basedir</key><value>/mnt/data/recordings</value></param>
<param><key>basefile</key><value>noaa</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>radioCenterFreq</key><value>radio_freq</value></param>
<param><key>honorFreqChange</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>filerepeater_MetaToPair</key>
<param><key>id</key><value>filerepeater_MetaToPair_0</value></param>
<param><key>keyin</key><value>el</value></param>
<param><key>keyout</key><value>el</value></param>
</block>
<block>
<key>filerepeater_StateAnd</key>
<param><key>id</key><value>filerepeater_StateAnd_0</value></param>
<param><key>comment</key><value>Signal and above min el</value></param>
</block>
<block>
<key>gpredict_MsgPairToVar</key>
<param><key>id</key><value>gpredict_MsgPairToVar_0</value></param>
<param><key>target</key><value>doppler_freq</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>comment</key><value>Must be "in view" according to gpredict</value></param>
<param><key>gpredict_port</key><value>7356</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>gpredict_rotor</key>
<param><key>id</key><value>gpredict_rotor_0</value></param>
<param><key>gpredict_port</key><value>4533</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>minEl</key><value>5.0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>lfast_low_pass_filter</key>
<param><key>id</key><value>lfast_low_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>filter_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>filter_cutoff*0.2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>lfast_low_pass_filter</key>
<param><key>id</key><value>lfast_low_pass_filter_0_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>filter_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>filter_cutoff*0.2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>lfast_low_pass_filter</key>
<param><key>id</key><value>lfast_low_pass_filter_0_1</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>comment</key><value>Elim bands from decision</value></param>
<param><key>cutoff_freq</key><value>4e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/10</value></param>
<param><key>width</key><value>4e3*0.2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>lfast_low_pass_filter</key>
<param><key>id</key><value>lfast_low_pass_filter_0_1_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>comment</key><value>Elim bands from decision</value></param>
<param><key>cutoff_freq</key><value>4e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/10</value></param>
<param><key>width</key><value>4e3*0.2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mesa_MaxPower</key>
<param><key>id</key><value>mesa_MaxPower_0</value></param>
<param><key>comment</key><value>Signal must be above state notify threshold</value></param>
<param><key>holdUpSec</key><value>6.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>framesToAvg</key><value>6</value></param>
<param><key>produceOut</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate/10</value></param>
<param><key>squelchThreshold</key><value>squelchThreshold</value></param>
<param><key>stateThreshold</key><value>squelchThreshold+4</value></param>
</block>
<block>
<key>mesa_MaxPower</key>
<param><key>id</key><value>mesa_MaxPower_0_0</value></param>
<param><key>comment</key><value>Signal must be above state notify threshold</value></param>
<param><key>holdUpSec</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>framesToAvg</key><value>6</value></param>
<param><key>produceOut</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate/10</value></param>
<param><key>squelchThreshold</key><value>squelchThreshold</value></param>
<param><key>stateThreshold</key><value>squelchThreshold+4</value></param>
</block>
<block>
<key>mesa_SourceSelector</key>
<param><key>id</key><value>mesa_SourceSelector_0</value></param>
<param><key>holdTime</key><value>2.0</value></param>
</block>
<block>
<key>mesa_ioselector</key>
<param><key>id</key><value>mesa_ioselector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>key</key><value>inputport</value></param>
<param><key>label</key><value>Input Index</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>key</key><value>state</value></param>
<param><key>label</key><value>Recording</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0_0</value></param>
<param><key>gui_hint</key><value>1,4,1,2</value></param>
<param><key>key</key><value>el</value></param>
<param><key>label</key><value>Elevation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/10</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,2,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>Unfiltered</value></param>
<param><key>name</key><value>South/Front</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>squelchThreshold-8</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate/10</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,2,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>unfiltered</value></param>
<param><key>name</key><value>North/Back</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>squelchThreshold-8</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>8,1,2,4</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Audio</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>squelchThreshold-10</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/10</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,0,2,3</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>squelchThreshold-10</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>South/Front</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/10</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,3,2,3</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>squelchThreshold-10</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>North/Back</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>comment</key><value>Downsample to 44.1KHz</value></param>
<param><key>decim</key><value>480</value></param>
<param><key>interp</key><value>441</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>comment</key><value>Downsample to 11025 Hz</value></param>
<param><key>decim</key><value>44100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>11025</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>grnet_udp_source</key>
<param><key>id</key><value>udp_src_5551</value></param>
<param><key>alias</key><value>udp_src_5551</value></param>
<param><key>comment</key><value>North - 5553</value></param>
<param><key>header</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>notifyMissed</key><value>True</value></param>
<param><key>port</key><value>5551+2</value></param>
<param><key>payloadsize</key><value>1472</value></param>
</block>
<block>
<key>grnet_udp_source</key>
<param><key>id</key><value>udp_src_5552</value></param>
<param><key>alias</key><value>udp_src_5552</value></param>
<param><key>comment</key><value>South - 5554</value></param>
<param><key>header</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>notifyMissed</key><value>True</value></param>
<param><key>port</key><value>5552+2</value></param>
<param><key>payloadsize</key><value>1472</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lfast_low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>lfast_low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_MetaToPair_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0_0_0</sink_block_id><source_key>outpair</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>state</source_key><sink_key>recordstate</sink_key></connection>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0_0</sink_block_id><source_key>state</source_key><sink_key>recordstate</sink_key></connection>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0_0</sink_block_id><source_key>state</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>edit_box_input_freq</sink_block_id><source_key>freq</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>gpredict_MsgPairToVar_0</sink_block_id><source_key>freq</source_key><sink_key>inpair</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>state</source_key><sink_key>state1</sink_key></connection>
<connection><source_block_id>gpredict_rotor_0</source_block_id><sink_block_id>filerepeater_MetaToPair_0</sink_block_id><source_key>az_el</source_key><sink_key>inmeta</sink_key></connection>
<connection><source_block_id>gpredict_rotor_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>state</source_key><sink_key>state2</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0</source_block_id><sink_block_id>mesa_ioselector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0_0</source_block_id><sink_block_id>mesa_ioselector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0_1</source_block_id><sink_block_id>mesa_MaxPower_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_low_pass_filter_0_1_0</source_block_id><sink_block_id>mesa_MaxPower_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_MaxPower_0</source_block_id><sink_block_id>mesa_SourceSelector_0</sink_block_id><source_key>maxpower</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>mesa_MaxPower_0_0</source_block_id><sink_block_id>mesa_SourceSelector_0</sink_block_id><source_key>maxpower</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>mesa_SourceSelector_0</source_block_id><sink_block_id>mesa_ioselector_0</sink_block_id><source_key>inputport</source_key><sink_key>inputindex</sink_key></connection>
<connection><source_block_id>mesa_SourceSelector_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>inputport</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>mesa_ioselector_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_ioselector_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>lfast_low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>lfast_low_pass_filter_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>udp_src_5551</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>udp_src_5552</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
