<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_autodoppler</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>expectedWidth</value></param>
<param><key>value</key><value>6100.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>filter_cutoff</value></param>
<param><key>value</key><value>expectedWidth</value></param>
<param><key>gui_hint</key><value>0,3,1,3</value></param>
<param><key>label</key><value>Filter Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>20000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_sample</value></param>
<param><key>value</key><value>int(samp_rate/stage1_decimation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host</value></param>
<param><key>value</key><value>'192.168.254.139'</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lna_gain</value></param>
<param><key>value</key><value>32</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>maxDrift</value></param>
<param><key>value</key><value>30000.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>monFilterCutoff</value></param>
<param><key>value</key><value>expectedWidth / 2.0 * 1.1 + maxDrift * 1.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_freq</value></param>
<param><key>comment</key><value>To use Doppler, this can't be tied to a GUI control</value></param>
<param><key>value</key><value>162.425e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rpitouch</value></param>
<param><key>value</key><value>'192.168.254.138'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_airspy</value></param>
<param><key>value</key><value>'airspy'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>src_spyserver</value></param>
<param><key>value</key><value>'host='+host+',port=5555,spyserver=0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>stage1_decimation</value></param>
<param><key>value</key><value>int(samp_rate/500e3)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>testshift</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,3</value></param>
<param><key>label</key><value>Test Shift</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>10000.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>2,0,1,3</value></param>
<param><key>label</key><value>VGA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>working_samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>audio_rate*10</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>testshift</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Volume Control</value></param>
<param><key>const</key><value>vol</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3</value></param>
<param><key>comment</key><value>NBFM.  12.5 kHz</value></param>
<param><key>cutoff_freq</key><value>expectedWidth/2.0</value></param>
<param><key>decim</key><value>int(samp_rate/working_samp_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>expectedWidth/2.0*0.2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3_0</value></param>
<param><key>comment</key><value>NBFM.  12.5 kHz</value></param>
<param><key>cutoff_freq</key><value>monFilterCutoff</value></param>
<param><key>decim</key><value>int(samp_rate/working_samp_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>monFilterCutoff*0.2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mesa_AutoDopplerCorrect</key>
<param><key>id</key><value>mesa_AutoDopplerCorrect_0</value></param>
<param><key>holdUpSec</key><value>10.0</value></param>
<param><key>expectedWidth</key><value>6100.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>framesToAvg</key><value>int(math.ceil(0.015*samp_rate/1024))</value></param>
<param><key>maxDrift</key><value>10000.0</value></param>
<param><key>processMessages</key><value>False</value></param>
<param><key>minWidth</key><value>samp_rate/1024*2.0</value></param>
<param><key>freq</key><value>radio_freq</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>shiftHolddownMS</key><value>3000</value></param>
<param><key>squelchThreshold</key><value>-75.0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>radio_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>lna_gain</value></param>
<param><key>gain0</key><value>lna_gain</value></param>
<param><key>args</key><value>src_spyserver</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,2,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Raw Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,2,3</value></param>
<param><key>label1</key><value>Original</value></param>
<param><key>label2</key><value>Corrected</value></param>
<param><key>name</key><value>"Corrected Input"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,3,2,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Audio</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>radio_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,0,2,3</value></param>
<param><key>int_max</key><value>-10</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Raw Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>mesa_AutoDopplerCorrect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_AutoDopplerCorrect_0</source_block_id><sink_block_id>low_pass_filter_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_AutoDopplerCorrect_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mesa_AutoDopplerCorrect_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>signaldetect</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>low_pass_filter_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
