options:
  parameters:
    generate_options: qt_gui
    id: TestLongTermIntegrator
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: skyfreq
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: int(65536/2)
  states: {}
- name: frequency
  id: variable
  parameters:
    value: skyfreq
  states: {}
- name: reset
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    label: Reset
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: skyfreq
  id: variable
  parameters:
    value: 1420.40575e6
  states: {}
- name: step_value
  id: variable
  parameters:
    value: samp_rate/decimation/fftsize
  states: {}
- name: xstart_value
  id: variable
  parameters:
    value: (center_freq-samp_rate/2/decimation)
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: lfast_nlog10volk_0_0
  id: lfast_nlog10volk
  parameters:
    comment: k=-30 converts dBm to dB
    k: '-10'
    n: '10'
    vlen: fftsize
  states: {}
- name: mesa_LongTermIntegrator_0
  id: mesa_LongTermIntegrator
  parameters:
    normalize: 'False'
    reset: reset
    vlength: fftsize
  states: {}
- name: mesa_LongTermIntegrator_0_0
  id: mesa_LongTermIntegrator
  parameters:
    normalize: 'True'
    reset: reset
    vlength: fftsize
  states: {}
- name: note_0
  id: note
  parameters:
    note: Hydrogen Line Integration
  states: {}
- name: osmosdr_source_0_1_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: frequency
    gain0: '24'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    is_pair: 'False'
    label: Elapsed Time
    type: string
    value: '''0 seconds'''
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"red"'
    gui_hint: 1,0,1,4
    name: CasA - 1420 MHz Long-Term Integration
    showports: 'True'
    update_time: '0.5'
    vlen: fftsize
    x_axis_label: Frequency
    x_start: xstart_value
    x_step: step_value
    x_units: Hz
    y_axis_label: Power
    ymax: '40'
    ymin: '20'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"red"'
    gui_hint: 2,0,1,4
    name: CasA - 1420 MHz - Normalized Long-Term Integration
    showports: 'True'
    update_time: '0.5'
    vlen: fftsize
    x_axis_label: Frequency
    x_start: xstart_value
    x_step: step_value
    x_units: Hz
    y_axis_label: Power
    ymax: '40'
    ymin: '20'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', mesa_LongTermIntegrator_0, '0']
- [blocks_integrate_xx_0_0, '0', mesa_LongTermIntegrator_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [lfast_nlog10volk_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [mesa_LongTermIntegrator_0, '0', lfast_nlog10volk_0_0, '0']
- [mesa_LongTermIntegrator_0, runtime, qtgui_edit_box_msg_0, val]
- [mesa_LongTermIntegrator_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [osmosdr_source_0_1_1, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
