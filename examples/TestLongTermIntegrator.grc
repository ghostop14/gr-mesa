<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TestLongTermIntegrator</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>skyfreq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>65536/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>skyfreq</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>reset</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Reset</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>skyfreq</value></param>
<param><key>value</key><value>1420.40575e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>step_value</value></param>
<param><key>value</key><value>samp_rate/decimation/fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xstart_value</value></param>
<param><key>value</key><value>(center_freq-samp_rate/2/decimation)</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0_0</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>lfast_nlog10volk</key>
<param><key>id</key><value>lfast_nlog10volk_0_0</value></param>
<param><key>comment</key><value>k=-30 converts dBm to dB</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-10</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>mesa_LongTermIntegrator</key>
<param><key>id</key><value>mesa_LongTermIntegrator_0</value></param>
<param><key>normalize</key><value>False</value></param>
<param><key>reset</key><value>reset</value></param>
<param><key>vlength</key><value>fftsize</value></param>
</block>
<block>
<key>mesa_LongTermIntegrator</key>
<param><key>id</key><value>mesa_LongTermIntegrator_0_0</value></param>
<param><key>normalize</key><value>True</value></param>
<param><key>reset</key><value>reset</value></param>
<param><key>vlength</key><value>fftsize</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Hydrogen Line Integration</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_1</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>24</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Elapsed Time</value></param>
<param><key>is_pair</key><value>False</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'0 seconds'</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>CasA - 1420 MHz Long-Term Integration</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>Frequency</value></param>
<param><key>x_start</key><value>xstart_value</value></param>
<param><key>x_step</key><value>step_value</value></param>
<param><key>x_units</key><value>Hz</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>20</value></param>
<param><key>y_axis_label</key><value>Power</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>CasA - 1420 MHz - Normalized Long-Term Integration</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>Frequency</value></param>
<param><key>x_start</key><value>xstart_value</value></param>
<param><key>x_step</key><value>step_value</value></param>
<param><key>x_units</key><value>Hz</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>20</value></param>
<param><key>y_axis_label</key><value>Power</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_integrate_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0_0</source_block_id><sink_block_id>mesa_LongTermIntegrator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0_0</source_block_id><sink_block_id>mesa_LongTermIntegrator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_nlog10volk_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_LongTermIntegrator_0</source_block_id><sink_block_id>lfast_nlog10volk_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_LongTermIntegrator_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>runtime</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>mesa_LongTermIntegrator_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
