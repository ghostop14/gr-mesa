options:
  parameters:
    generate_options: qt_gui
    id: test_autocorrelator
    output_language: python
  states: {}

blocks:
- name: fac_decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fac_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2441e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: window_time
  id: variable
  parameters:
    value: samp_rate/fac_size
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fac_size
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mesa_AutoCorrelatorSink_1
  id: mesa_AutoCorrelatorSink
  parameters:
    autoScale: 'False'
    fac_decimation: '10'
    fac_size: '512'
    grid: 'True'
    gui_hint: 2,0,1,3
    sampRate: samp_rate
    title: Fast Autocorrelation Sink
    useDB: 'False'
    yMax: '1'
    yMin: '0'
  states: {}
- name: mesa_AutoCorrelator_0
  id: mesa_AutoCorrelator
  parameters:
    fac_decimation: fac_decimation
    fac_size: fac_size
    sampRate: samp_rate
    useDB: 'False'
  states: {}
- name: mesa_Normalize_0
  id: mesa_Normalize
  parameters:
    vecsize: fac_size
  states: {}
- name: note_0
  id: note
  parameters:
    note: Access to the Correlated Data
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Direct Plot
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,3
    plotconst: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,3
    label1: ''
    legend: 'False'
    name: Fast Autocorrelation
    size: int(fac_size/2)
    srate: samp_rate
    type: float
    ylabel: dB
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', mesa_AutoCorrelatorSink_1, '0']
- [blocks_throttle_0, '0', mesa_AutoCorrelator_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [mesa_AutoCorrelator_0, '0', mesa_Normalize_0, '0']
- [mesa_Normalize_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
