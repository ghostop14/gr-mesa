<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>noaa_relay_south</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host</value></param>
<param><key>comment</key><value>225 = sigintsouth
206 = sigintnorth
99 sigintwifi / 100 wired</value></param>
<param><key>value</key><value>'192.168.254.225'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_15</value></param>
<param><key>value</key><value>137.62e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_18</value></param>
<param><key>value</key><value>137.9125e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noaa_19</value></param>
<param><key>value</key><value>137.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_freq</value></param>
<param><key>value</key><value>noaa_19</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target</value></param>
<param><key>value</key><value>'192.168.254.20'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transmit_rate</value></param>
<param><key>value</key><value>480e3</value></param>
</block>
<block>
<key>correctiq_correctiq</key>
<param><key>id</key><value>correctiq_correctiq_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>grnet_udp_sink</key>
<param><key>id</key><value>grnet_udp_sink_0</value></param>
<param><key>addr</key><value>target</value></param>
<param><key>port</key><value>5554</value></param>
<param><key>header</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>send_eof</key><value>False</value></param>
<param><key>payloadsize</key><value>1472</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_1</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>radio_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>rtl,bias=1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_1_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>radio_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>comment</key><value>Airspy Config</value></param>
<param><key>args</key><value>airspy,bias=1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Drop to 480K</value></param>
<param><key>decim</key><value>int(samp_rate/transmit_rate)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>comment</key><value>Drop to 480K</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>correctiq_correctiq_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1</source_block_id><sink_block_id>correctiq_correctiq_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_1_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>grnet_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
